FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://spi.cfg"
